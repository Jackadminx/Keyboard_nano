# Keil uVision project proj.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH549 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(48000000)
  output: proj +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Lib
  group Source Group 1
    ./: STARTUP.A51
    ./User/: main.C
  group Lib
    ./Lib/: DEBUG.C GPIO.C FlashRom.C RGB.C WS2812B.C WS2812B.H
